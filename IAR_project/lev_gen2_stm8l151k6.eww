<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ev_stm8l151k6_emotor.ewp</path>
  </project>
  <batchBuild/>
</workspace>


