# IAR project ev_stm8l151k6_emotor.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x150
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\STM8L15x_StdPeriph_Lib_V1.5.1\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\STM8L15x_StdPeriph_Lib_V1.5.1\Libraries\STM8L15x_StdPeriph_Driver\src; ..\Emotor_Sources; ..\Emotor_Sources\Config_Info\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ev_stm8l151k6_emotor.hex
  ILINK.IlinkOutputFile: ev_stm8l151k6_emotor.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group _Utilities
    ../Emotor_Sources/Utilities/: Modbus_CRC.c
  group Config_Info
    ../Emotor_Sources/Config_Info/: EEPROM_UserDefine_Ver_History.txt FW_Version_Define.h System_Config_Info.h
  group Coulomb_Counter
    ../Emotor_Sources/Coulomb_Counter/: coulomb_counter.c coulomb_counter.h OCV_Table_LGC_26B4_10S.h OCV_Table_LGC_26B4_13S.h OCV_Table_LGC_26B4_7S.h OCV_Table_LGC_26B4_8S.h OCV_Table_SDI_22FM_10S.h OCV_Table_SDI_22FM_13S.h OCV_Table_SDI_22FM_7S.h OCV_Table_SDI_22FM_8S.h OCV_Table_SDI_26F_10S.h OCV_Table_SDI_26F_13S.h OCV_Table_SDI_26F_5S.h OCV_Table_SDI_26F_7S.h OCV_Table_SDI_26H_10S.h OCV_Table_SDI_29E_10S.h OCV_Table_SDI_29E_13S.h OCV_Table_SDI_29E_7S.h OCV_Table_SDI_29E_8S.h
  group Drivers
    ../Emotor_Sources/Drivers/: ADC_config.c BackLightControl.c Button.c Clock_config.c Drivers.h EEPROM_Access.c GPIO_LowPowerConfig.c InputSignalControl.c LED_PWM_Control.c Mos_Control.c OutputSignalControl.c RTC_config.c Timer1.c Timer2.c Timer3.c Timer4.c USART1.c UsbOutputPowerControl.c WatchDog.c
  group SOC
    ../Emotor_Sources/SOC/: Calculate_NTC_ADC_TO_TEMPERATURE.c Calculate_NTC_ADC_TO_TEMPERATURE.h SOC_With_Temperature_Calculation.c SOC_With_Temperature_Calculation.h SOC_With_Voltage_Calculation.c
  group SOC/inc_SOC_10S_SDI_26F
    ../Emotor_Sources/SOC/inc_SOC_10S_SDI_26F/: SOC_TABLE_CHG_10S_3P_WITH_TEMP_26F.h SOC_TABLE_CHG_10S_4P_WITH_TEMP_26F.h SOC_TABLE_CHG_10S_5P_WITH_TEMP_26F.h SOC_TABLE_CHG_10S_6P_WITH_TEMP_26F.h SOC_TABLE_CHG_10S_7P_WITH_TEMP_26F.h SOC_TABLE_DSG_10S_3P_4P_5P_WITH_TEMP_26F.h SOC_TABLE_DSG_10S_6P_7P_WITH_TEMP_26F.h SOC_TABLE_STATIC_10S_3P_4P_5P_6P_7P_OCV_26F.h
  group SOC/inc_SOC_10S_SDI_26H
    ../Emotor_Sources/SOC/inc_SOC_10S_SDI_26H/: SOC_TABLE_CHG_10S_3P_WITH_TEMP_26H.h SOC_TABLE_CHG_10S_4P_WITH_TEMP_26H.h SOC_TABLE_CHG_10S_5P_WITH_TEMP_26H.h SOC_TABLE_DSG_10S_3P_4P_5P_WITH_TEMP_26H.h SOC_TABLE_DSG_10S_3P_4P_WITH_TEMP_26H.h SOC_TABLE_STATIC_10S_3P_4P_5P_OCV_26H.h SOC_TABLE_STATIC_10S_3P_4P_OCV_26H.h
  group SOC/inc_SOC_13S_SDI_22H
    ../Emotor_Sources/SOC/inc_SOC_13S_SDI_22H/: SOC_TABLE_CHG_13S_3P_WITH_TEMP_22H.h SOC_TABLE_CHG_13S_4P_WITH_TEMP_22H.h SOC_TABLE_DSG_13S_3P_4P_WITH_TEMP_22H.h SOC_TABLE_STATIC_13S_3P_4P_OCV_22H.h
  group SOC/inc_SOC_13S_SDI_26F
    ../Emotor_Sources/SOC/inc_SOC_13S_SDI_26F/: SOC_TABLE_CHG_13S_3P_WITH_TEMP_26F.h SOC_TABLE_CHG_13S_4P_WITH_TEMP_26F.h SOC_TABLE_CHG_13S_5P_WITH_TEMP_26F.h SOC_TABLE_DSG_13S_3P_4P_5P_WITH_TEMP_26F.h SOC_TABLE_STATIC_13S_3P_4P_5P_OCV_26F.h
  group SOC/inc_SOC_13S_SDI_26H
    ../Emotor_Sources/SOC/inc_SOC_13S_SDI_26H/: SOC_TABLE_CHG_13S_3P_WITH_TEMP_26H.h SOC_TABLE_CHG_13S_4P_WITH_TEMP_26H.h SOC_TABLE_CHG_13S_5P_WITH_TEMP_26H.h SOC_TABLE_DSG_13S_3P_4P_5P_WITH_TEMP_26H.h SOC_TABLE_DSG_13S_3P_4P_WITH_TEMP_26H.h SOC_TABLE_STATIC_13S_3P_4P_5P_OCV_26H.h SOC_TABLE_STATIC_13S_3P_4P_OCV_26H.h
  group SOC/inc_SOC_5S_SDI_26F
    ../Emotor_Sources/SOC/inc_SOC_5S_SDI_26F/: SOC_TABLE_CHG_5S_1P_WITH_TEMP_26F.h SOC_TABLE_DSG_5S_1P_WITH_TEMP_26F.h SOC_TABLE_STATIC_5S_OCV_26F.h
  group SOC/inc_SOC_7S_SDI_26F
    ../Emotor_Sources/SOC/inc_SOC_7S_SDI_26F/: SOC_TABLE_CHG_7S_3P_WITH_TEMP_26F.h SOC_TABLE_CHG_7S_4P_WITH_TEMP_26F.h SOC_TABLE_CHG_7S_6P_WITH_TEMP_26F.h SOC_TABLE_DSG_7S_3P_4P_5P_6P_WITH_TEMP_26F.h SOC_TABLE_STATIC_7S_OCV_26F.h
  group SOC/inc_SOC_7S_SDI_26H
    ../Emotor_Sources/SOC/inc_SOC_7S_SDI_26H/: SOC_TABLE_CHG_7S_2P_WITH_TEMP_26H.h SOC_TABLE_CHG_7S_3P_WITH_TEMP_26H.h SOC_TABLE_CHG_7S_4P_WITH_TEMP_26H.h SOC_TABLE_DSG_7S_2P_WITH_TEMP_26H.h SOC_TABLE_DSG_7S_3P_4P_WITH_TEMP_26H.h SOC_TABLE_STATIC_7S_2P_3P_4P_OCV_26H.h
  group SOC/NTC
    ../Emotor_Sources/SOC/: NTC_ADC_TO_TEMP_Table__MITSUBISHI_H_TYPE_3370.h NTC_ADC_TO_TEMP_Table__MITSUBISHI_H_TYPE_3413.h NTC_ADC_TO_TEMP_Table__MITSUBISHI_J_TYPE_3450.h NTC_ADC_TO_TEMP_Table__THINKING_TYPE_3435.h
  group Source
    ../Emotor_Sources/: Capacity_Display_Polling_Func.c Capacity_Display_Polling_Func.h Current_Count_SOC_Function.c Current_Count_SOC_Function.h Driver_User_Interface.c Driver_User_Interface.h Driver_User_Interface_For_Uart.c Global_Variable_Define.h main.c Main_Sub_Functions.c Protection_Polling_Func.c Protection_Polling_Func.h RecordingData.c Remark_Templates.c Timer_Polling_Func.c Vars_Bits_Define.h
  group STM8L15x_Lib/inc
    ../STM8L15x_StdPeriph_Lib_V1.5.1/Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_iwdg.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_usart.h stm8l15x_wwdg.h
  group STM8L15x_Lib/src
    ../STM8L15x_StdPeriph_Lib_V1.5.1/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_usart.c stm8l15x_wwdg.c
