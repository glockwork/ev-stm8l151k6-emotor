# IAR project lev_gen2_stm8l151k6.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K6 STM8L151K6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x150
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..; ..\STM8L15x_StdPeriph_Lib_V1.5.1\Libraries\STM8L15x_StdPeriph_Driver\inc; ..\STM8L15x_StdPeriph_Lib_V1.5.1\Libraries\STM8L15x_StdPeriph_Driver\src; ..\Source_Codes; ..\Source_Codes\Config_Info\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: lev_gen2_stm8l151k6.hex
  prebuild: ..\Bin_Tools\PreBuild.bat $PROJ_DIR$
  ILINK.IlinkOutputFile: lev_gen2_stm8l151k6.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkExtraOptions: ..\Bin_Tools\LEV_Console_Change_Name.exe
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group _Utilities
    ../Source_Codes/Utilities/: Modbus_CRC.c
  group Config_Info
    ../Source_Codes/Config_Info/: FW_Version_Define.h System_Config_Info.h
    ../Bin_Tools/: PreBuild.bat
  group Config_Info/Old_Version
    ../Source_Codes/Config_Info/: UserDefine_Ares_TB_36100NB_36100_10S4P4LED_SDI26H_SAMPLES.h UserDefine_Aurola_A120603_10S_4P_5LED_SDI26F.h UserDefine_Aurola_A120603_10S_4P_5LED_SDI26H.h UserDefine_Ceres_A120604_10S_3P_0LED_SDI26F.h UserDefine_Ceres_A120604_10S_3P_0LED_SDI26H.h UserDefine_Cupid_7S2P5LED_SDI26H_SAMPLES.h UserDefine_Cupid_7S3P5LED_SDI26H_SAMPLES.h UserDefine_Demeter_A_13S_4P_3LED_SDI22H_SAMPLES.h UserDefine_Demeter_B_13S_4P_3LED_SDI26H_SAMPLES.h UserDefine_Demeter_B_PLUS_10S_4P_3LED_SDI26H_SAMPLES.h UserDefine_Dolphin_B300_36100_10S4P4LED_SDI26H_SAMPLES.h UserDefine_Eos_A120701_10S_3P_4LED_SDI26F.h UserDefine_Eos_A120701_10S_3P_4LED_SDI26H.h UserDefine_old_A1207_1_LEARNING_10S3P4LED_SDI26H.h UserDefine_Pan_10S4P3LED_SDI26H_SAMPLES.h UserDefine_Pan_10S4P4LED_SDI26H_SAMPLES_Test.h UserDefine_Pan_7S3P3LED_SDI26H_SAMPLES.h UserDefine_Pan_B285_36100_10S_4P_3LED_SDI26H_SAMPLES.h UserDefine_Pan_B285_36130_10S_5P_3LED_SDI26H_SAMPLES.h UserDefine_Thallo_TouchKey_13S_4P_4LED_SDI26H_SAMPLES.h
  group Coulomb_Counter
    ../Source_Codes/Coulomb_Counter/: coulomb_counter.c coulomb_counter.h OCV_Table_LGC_26B4_10S.h OCV_Table_LGC_26B4_13S.h OCV_Table_LGC_26B4_7S.h OCV_Table_LGC_26B4_8S.h OCV_Table_SDI_26F_10S.h OCV_Table_SDI_26F_13S.h OCV_Table_SDI_26F_7S.h OCV_Table_SDI_26H_10S.h OCV_Table_SDI_29E_10S.h OCV_Table_SDI_29E_13S.h OCV_Table_SDI_29E_7S.h OCV_Table_SDI_29E_8S.h
  group Drivers
    ../Source_Codes/Drivers/: ADC_config.c BackLightControl.c Button.c Clock_config.c Drivers.h EEPROM_Access.c GPIO_LowPowerConfig.c InputSignalControl.c LED_PWM_Control.c Mos_Control.c OutputSignalControl.c RTC_config.c Timer1.c Timer2.c Timer3.c Timer4.c USART1.c UsbOutputPowerControl.c WatchDog.c
  group SOC
    ../Source_Codes/SOC/: Calculate_NTC_ADC_TO_TEMPERATURE.c Calculate_NTC_ADC_TO_TEMPERATURE.h NTC_ADC_TO_TEMP_Table__MITSUBISHI_H_TYPE_3370.h NTC_ADC_TO_TEMP_Table__MITSUBISHI_J_TYPE_3450.h SOC_With_Temperature_Calculation.c SOC_With_Temperature_Calculation.h SOC_With_Voltage_Calculation.c
  group SOC/inc_SOC_10S_SDI_26F
    ../Source_Codes/SOC/inc_SOC_10S_SDI_26F/: SOC_TABLE_CHG_10S_3P_WITH_TEMP_26F.h SOC_TABLE_CHG_10S_4P_WITH_TEMP_26F.h SOC_TABLE_CHG_10S_5P_WITH_TEMP_26F.h SOC_TABLE_CHG_10S_6P_WITH_TEMP_26F.h SOC_TABLE_CHG_10S_7P_WITH_TEMP_26F.h SOC_TABLE_DSG_10S_3P_4P_5P_WITH_TEMP_26F.h SOC_TABLE_DSG_10S_6P_7P_WITH_TEMP_26F.h SOC_TABLE_STATIC_10S_3P_4P_5P_6P_7P_OCV_26F.h
  group SOC/inc_SOC_10S_SDI_26H
    ../Source_Codes/SOC/inc_SOC_10S_SDI_26H/: SOC_TABLE_CHG_10S_3P_WITH_TEMP_26H.h SOC_TABLE_CHG_10S_4P_WITH_TEMP_26H.h SOC_TABLE_CHG_10S_5P_WITH_TEMP_26H.h SOC_TABLE_DSG_10S_3P_4P_5P_WITH_TEMP_26H.h SOC_TABLE_DSG_10S_3P_4P_WITH_TEMP_26H.h SOC_TABLE_DSG_10S_3P_4P_WITH_TEMP_26H_old.h SOC_TABLE_DSG_10S_3P_4P_WITH_TEMP_26H_org.h SOC_TABLE_STATIC_10S_3P_4P_5P_OCV_26H.h SOC_TABLE_STATIC_10S_3P_4P_OCV_26H.h
  group SOC/inc_SOC_13S_SDI_22H
    ../Source_Codes/SOC/inc_SOC_13S_SDI_22H/: SOC_TABLE_CHG_13S_3P_WITH_TEMP_22H.h SOC_TABLE_CHG_13S_4P_WITH_TEMP_22H.h SOC_TABLE_DSG_13S_3P_4P_WITH_TEMP_22H.h SOC_TABLE_STATIC_13S_3P_4P_OCV_22H.h
  group SOC/inc_SOC_13S_SDI_26F
    ../Source_Codes/SOC/inc_SOC_13S_SDI_26F/: SOC_TABLE_CHG_13S_3P_WITH_TEMP_26F.h SOC_TABLE_CHG_13S_4P_WITH_TEMP_26F.h SOC_TABLE_CHG_13S_5P_WITH_TEMP_26F.h SOC_TABLE_DSG_13S_3P_4P_5P_WITH_TEMP_26F.h SOC_TABLE_STATIC_13S_3P_4P_5P_OCV_26F.h
  group SOC/inc_SOC_13S_SDI_26H
    ../Source_Codes/SOC/inc_SOC_13S_SDI_26H/: SOC_TABLE_CHG_13S_3P_WITH_TEMP_26H.h SOC_TABLE_CHG_13S_4P_WITH_TEMP_26H.h SOC_TABLE_DSG_13S_3P_4P_WITH_TEMP_26H.h SOC_TABLE_STATIC_13S_3P_4P_OCV_26H.h
  group SOC/inc_SOC_7S_SDI_26F
    ../Source_Codes/SOC/inc_SOC_7S_SDI_26F/: SOC_TABLE_CHG_7S_3P_WITH_TEMP_26F.h SOC_TABLE_CHG_7S_4P_WITH_TEMP_26F.h SOC_TABLE_CHG_7S_6P_WITH_TEMP_26F.h SOC_TABLE_DSG_7S_3P_4P_5P_6P_WITH_TEMP_26F.h SOC_TABLE_STATIC_7S_OCV_26F.h
  group SOC/inc_SOC_7S_SDI_26H
    ../Source_Codes/SOC/inc_SOC_7S_SDI_26H/: SOC_TABLE_CHG_7S_2P_WITH_TEMP_26H.h SOC_TABLE_CHG_7S_3P_WITH_TEMP_26H.h SOC_TABLE_DSG_7S_2P_WITH_TEMP_26H.h SOC_TABLE_DSG_7S_3P_WITH_TEMP_26H.h SOC_TABLE_STATIC_7S_2P_3P_OCV_26H.h
  group Source
    ../Source_Codes/: Capacity_Display_Polling_Func.c Capacity_Display_Polling_Func.h Current_Count_SOC_Function.c Current_Count_SOC_Function.h Driver_User_Interface.c Driver_User_Interface.h Driver_User_Interface_For_Uart.c Global_Variable_Define.h main.c Main_Sub_Functions.c Module_Control_Func.c Protection_Polling_Func.c Protection_Polling_Func.h RecordingData.c Remark_Templates.c stm8_interrupt_vector.c stm8l15x_it.c stm8l15x_it.h Timer_Polling_Func.c Vars_Bits_Define.h
  group STM8L15x_Lib/inc
    ../STM8L15x_StdPeriph_Lib_V1.5.1/Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_clk.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_iwdg.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_usart.h stm8l15x_wwdg.h
  group STM8L15x_Lib/src
    ../STM8L15x_StdPeriph_Lib_V1.5.1/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_usart.c stm8l15x_wwdg.c
  group z_Discovery
    ../STM8L152_Discovery/src/: delay.c discover_functions.c eeprom.c icc_measure.c main.c stm8_interrupt_vector.c stm8l15x_it.c stm8l_discovery_lcd.c
    ../STM8L152_Discovery/inc/: delay.h discover_board.h discover_functions.h icc_measure.h stm8l15x_it.h stm8l_discovery_lcd.h
  group z_Example/ADC
    ../STM8L15x_StdPeriph_Lib_V1.5.1/Project/STM8L15x_StdPeriph_Examples/ADC/ADC_IDD_measurement/: main.c stm8l15x_it.c stm8l15x_it.h
  group z_Example/Timer
    ../STM8L15x_StdPeriph_Lib_V1.5.1/Project/STM8L15x_StdPeriph_Examples/TIM4/TIM4_TimeBase/: main.c stm8l15x_it.c
